# Keil uVision project CeDingZhanRTOS.uvprojx, settings and files
target CeDingZhanRTOS (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: CeDingZhanRTOS +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M ATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\TFT;..\HARDWARE\RFID;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\HARDWARE\FATFS;..\HARDWARE\WEIGHT;..\HARDWARE\WEIGHT\ads1263;..\HARDWARE\WEIGHT\DSP_Lib\Include;..\HARDWARE\WEIGHT\Load_Sensor;..\HARDWARE\WEIGHT\my_spi;..\HARDWARE\WEIGHT\TIMER;..\HARDWARE\CAN;..\HARDWARE\HARDCONTROL;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c user_task.c cJSON.c myString.c
  group HARDCONTROL
    ../HARDWARE/HARDCONTROL/: hardcontrol.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TFT/: cmd_queue.c hmi_driver.c hmi_user_uart.c cmd_process.c
    ../HARDWARE/IWDG/: iwdg.c
  group RFID
    ../HARDWARE/RFID/: uart_rfid.c
  group WEIGHT
    ../HARDWARE/WEIGHT/ads1263/: ADS126x.c
    ../HARDWARE/WEIGHT/DSP_Lib/: math_helper.c arm_cortexM4lf_math.lib
    ../HARDWARE/WEIGHT/Load_Sensor/: Load_Sensor.c
    ../HARDWARE/WEIGHT/my_spi/: my_spi.c
    ../HARDWARE/WEIGHT/TIMER/: timer.c
  group CAN
    ../HARDWARE/CAN/: can.c
  group 24CXX
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_5.c
  group FATFS
    ../HARDWARE/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c exfuns.c
  group SDIO
    ../HARDWARE/SDIO/: sdio_sdcard.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_can.c stm32f4xx_i2c.c stm32f4xx_iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SRAM
    ../HARDWARE/SRAM/: sram.c
  group README
    ../: readme.txt
